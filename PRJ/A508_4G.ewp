# IAR project A508_4G.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S007C8 STM8S007C8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S007
  ICCSTM8.CCIncludePath2: ..\INCLUDE; ..\User; ..\Lib\inc; ..\Suport; ..\Drv\DrvGT20L16P1Y\new
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: A508_4G.hex
  ILINK.IlinkOutputFile: A508_4G.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group API
    ../Api/: ApiAtCmd.c ApiBattery.c ApiDelay.c ApiDisplay.c ApiGpsCmd.c ApiKeyboard.c ApiKeyCmd.c ApiLED.c ApiMcuVersion.c ApiMenu.c ApiPocCmd.c ApiVoice.c
  group DRV
    ../Drv/: DrvBeep.c DrvEeprom.c DrvKeyboard.c DrvKeyscan.c DrvMcuPin.c DrvTone.c DrvUart1.c DrvUart3.c DrvZM389.c
  group DRV/DrvDisplay
    ../Drv/: DrvGT20L16S1Y.c DrvHTG12832.c GT20L16_STM8_DOUBLE_MEDIUM_IAR.a
    ../Drv/DrvGT20L16P1Y/new/: GT20L16P1Y2.h GT20L16P1Y_STM8S007C8_IAR.a
    ../Drv/DrvGT20L16P1Y/: GT20L16P1Y_D.c
  group INCLUDE
    ../INCLUDE/: AllHead.h ApiAtCmd.h ApiBattery.h ApiDelay.h ApiDisplay.h ApiGpsCmd.h ApiKeyboard.h ApiLED.h ApiMcuVersion.h ApiPocCmd.h ApiVoice.h DataStructAddr.h DrvBeep.h DrvEeprom.h DrvFont.h DrvGT20L16S1Y.h DrvHTG12832.h DrvI2cAw87319.h DrvKeyboard.h DrvKeyscan.h DrvMcuPin.h DrvUart1.h DrvUart3.h DrvZM389.h GT20L16P1Y.h GT20L16P1Y_D.h main.h sysclock.h Task.h
    ../Suport/: UTF8toUNICODE.h
  group Lib
    ../Lib/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_uart4.c stm8s_wwdg.c
  group SUPORT
    ../Suport/: CommonLib.c sysclock.c UTF8toUNICODE.c
  group USER
    ../User/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h Task.c
